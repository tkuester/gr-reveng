options:
  parameters:
    category: Custom
    comment: |-
      This flowgraph builds a simple packet, and sends
      it through the Deframer. Try modifying the
      packet structure and parameters to test your
      understanding of how the deframer works!
    generate_options: qt_gui
    id: reveng_simple_test
    output_language: python
  states: {}

blocks:
- name: csum
  id: variable
  parameters:
    comment: |-
      A one byte checksum, not included in the length.
      (Set to 0x55 as a placeholder!)
    value: '0x55'
  states: {}
- name: csum_bits
  id: variable
  parameters:
    comment: |-
      A one byte checksum, not included in the length.
      Each bit is represented by an X's.
      (reveng works with symbols!)
    value: list(map(int, bin(csum)[2:].zfill(8)))
  states: {}
- name: msg
  id: variable
  parameters:
    comment: The message to send.
    value: '"Hello world!"'
  states: {}
- name: msg_bits
  id: variable
  parameters:
    value: list(map(int, bin(int(hex(msg.encode()), 16))[2:].zfill(8 * pktlen)))
  states: {}
- name: pktlen
  id: variable
  parameters:
    comment: |-
      How many bytes to transmit in the
      data section.
    value: len(msg)
  states: {}
- name: pktlen_bits
  id: variable
  parameters:
    value: list(map(int, bin(pktlen )[2:].zfill(8)))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sync_word
  id: variable
  parameters:
    comment: ChipCon likes 0xd391!
    value: '0xd391'
  states: {}
- name: sync_word_bits
  id: variable
  parameters:
    value: list(map(int, bin(sync_word)[2:].zfill(16)))
  states: {}
- name: transmitter_id
  id: variable
  parameters:
    comment: The transmitter ID is 0xdeadbeef
    value: '0xdeadbeef'
  states: {}
- name: transmitter_id_bits
  id: variable
  parameters:
    value: list(map(int, bin(transmitter_id)[2:].zfill(32)))
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: |-
      Remember, each "byte" on screen is actually
      a bit!
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Modify the packet structure here!
    repeat: 'True'
    type: byte
    vector: sync_word_bits + transmitter_id_bits + pktlen_bits + msg_bits + csum_bits + [0]*10000
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from binascii import hexlify as hex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      ***********************************
      * MESSAGE DEBUG PRINT PDU VERBOSE *
      ((ts . 1.50074e+09) (packed . #f) (name . RevengTestSrc))
      pdu_length = 144
      contents = 
      0000: 01 01 00 01 01 01 01 00 01 00 01 00 01 01 00 01 
      0010: 01 00 01 01 01 01 01 00 01 01 01 00 01 01 01 01 
      0020: 00 00 00 00 01 01 00 00 00 01 00 00 01 00 00 00 
      0030: 00 01 01 00 00 01 00 01 00 01 01 00 01 01 00 00 
      0040: 00 01 01 00 01 01 00 00 00 01 01 00 01 01 01 01 
      0050: 00 00 01 00 00 00 00 00 00 01 01 01 00 01 01 01 
      0060: 00 01 01 00 01 01 01 01 00 01 01 01 00 00 01 00 
      0070: 00 01 01 00 01 01 00 00 00 01 01 00 00 01 00 00 
      0080: 00 00 01 00 00 00 00 01 00 01 00 01 00 01 00 01 
      ***********************************

      0000 - 0010: 0xdeadbeef, in bit form
      0020: The length byte, and the start of the message
      0088: The end of the message, and the checksum
  states: {}
- name: reveng_packet_deframer_0
  id: reveng_packet_deframer
  parameters:
    big_endian: 'True'
    encoding: none
    fixed_len: 'False'
    max_len: '0'
    msb: 'True'
    name: RevengTestSrc
    pack_bytes: 'False'
    pkt_len: '2'
    pkt_len_adj: '1'
    pkt_len_offset: '4'
    sync: sync_word_bits
  states: {}
- name: reveng_packet_formatter_0
  id: reveng_packet_formatter
  parameters:
    append: 'False'
    comment: The new Packet Formatter object!
    file_name: ''
    flush: 'True'
    format_str: '%(name)\nFull Packet: %(hex)\ntransmitter_id: %(hex[0:32])\nPacket Length: %(int[32:40])\nMessage: %(ascii[40:-8])\nChecksum: %(hex[-8:])\n'
    log_to: '"stdout"'
  states: {}

connections:
- [blocks_throttle_0, '0', reveng_packet_deframer_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [reveng_packet_deframer_0, out, blocks_message_debug_0, print_pdu]
- [reveng_packet_deframer_0, out, reveng_packet_formatter_0, pdus]

metadata:
  file_format: 1
