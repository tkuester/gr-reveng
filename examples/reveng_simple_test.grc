<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>reveng_simple_test</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>comment</key><value>This flowgraph builds a simple packet, and sends
it through the Deframer. Try modifying the
packet structure and parameters to test your
understanding of how the deframer works!</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>csum</value></param>
<param><key>comment</key><value>A one byte checksum, not included in the length.
(Set to 0x55 as a placeholder!)</value></param>
<param><key>value</key><value>0x55</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>csum_bits</value></param>
<param><key>comment</key><value>A one byte checksum, not included in the length.
Each bit is represented by an X's.
(reveng works with symbols!)</value></param>
<param><key>value</key><value>map(int, bin(csum)[2:].zfill(8))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>msg</value></param>
<param><key>comment</key><value>The message to send.</value></param>
<param><key>value</key><value>"Hello world!"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>msg_bits</value></param>
<param><key>value</key><value>map(int, bin(int(msg.encode('hex'), 16))[2:].zfill(8 * pktlen))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pktlen</value></param>
<param><key>comment</key><value>How many bytes to transmit in the
data section.</value></param>
<param><key>value</key><value>len(msg)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pktlen_bits</value></param>
<param><key>value</key><value>map(int, bin(pktlen )[2:].zfill(8))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word</value></param>
<param><key>comment</key><value>ChipCon likes 0xd391!</value></param>
<param><key>value</key><value>0xd391</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word_bits</value></param>
<param><key>value</key><value>map(int, bin(sync_word)[2:].zfill(16))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transmitter_id</value></param>
<param><key>comment</key><value>The transmitter ID is 0xdeadbeef</value></param>
<param><key>value</key><value>0xdeadbeef</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transmitter_id_bits</value></param>
<param><key>value</key><value>map(int, bin(transmitter_id)[2:].zfill(32))</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>comment</key><value>Remember, each "byte" on screen is actually
a bit!</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>comment</key><value>Modify the packet structure here!</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>sync_word_bits + transmitter_id_bits + pktlen_bits + msg_bits + csum_bits + [0]*10000</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>***********************************
* MESSAGE DEBUG PRINT PDU VERBOSE *
((ts . 1.50074e+09) (packed . #f) (name . RevengTestSrc))
pdu_length = 144
contents = 
0000: 01 01 00 01 01 01 01 00 01 00 01 00 01 01 00 01 
0010: 01 00 01 01 01 01 01 00 01 01 01 00 01 01 01 01 
0020: 00 00 00 00 01 01 00 00 00 01 00 00 01 00 00 00 
0030: 00 01 01 00 00 01 00 01 00 01 01 00 01 01 00 00 
0040: 00 01 01 00 01 01 00 00 00 01 01 00 01 01 01 01 
0050: 00 00 01 00 00 00 00 00 00 01 01 01 00 01 01 01 
0060: 00 01 01 00 01 01 01 01 00 01 01 01 00 00 01 00 
0070: 00 01 01 00 01 01 00 00 00 01 01 00 00 01 00 00 
0080: 00 00 01 00 00 00 00 01 00 01 00 01 00 01 00 01 
***********************************

0000 - 0010: 0xdeadbeef, in bit form
0020: The length byte, and the start of the message
0088: The end of the message, and the checksum</value></param>
</block>
<block>
<key>reveng_packet_deframer</key>
<param><key>id</key><value>reveng_packet_deframer_0</value></param>
<param><key>pkt_len_adj</key><value>1</value></param>
<param><key>encoding</key><value>none</value></param>
<param><key>big_endian</key><value>True</value></param>
<param><key>pkt_len_offset</key><value>4</value></param>
<param><key>msb</key><value>True</value></param>
<param><key>max_len</key><value>0</value></param>
<param><key>fixed_len</key><value>False</value></param>
<param><key>name</key><value>RevengTestSrc</value></param>
<param><key>pack_bytes</key><value>False</value></param>
<param><key>pkt_len</key><value>2</value></param>
<param><key>sync</key><value>sync_word_bits</value></param>
</block>
<block>
<key>reveng_packet_formatter</key>
<param><key>id</key><value>reveng_packet_formatter_0</value></param>
<param><key>append</key><value>False</value></param>
<param><key>comment</key><value>The new Packet Formatter object!</value></param>
<param><key>file_name</key><value></value></param>
<param><key>flush</key><value>True</value></param>
<param><key>format_str</key><value>%(name)\nFull Packet: %(hex)\ntransmitter_id: %(hex[0:32])\nPacket Length: %(int[32:40])\nMessage: %(ascii[40:-8])\nChecksum: %(hex[-8:])\n</value></param>
<param><key>log_to</key><value>"stdout"</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>reveng_packet_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>reveng_packet_deframer_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>reveng_packet_deframer_0</source_block_id><sink_block_id>reveng_packet_formatter_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
