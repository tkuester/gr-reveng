<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>reveng_simple_test</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>comment</key><value>This must be run from the cmdline.
Try adding and removing components to
test your understanding of the packet block.
The last data bit is a 'C', if you see it, then you
captured the data portion correctly!</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>csum</value></param>
<param><key>comment</key><value>A one byte checksum, not included in the length.
Represented by X's.</value></param>
<param><key>value</key><value>[ord('X')] * 8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>host_id</value></param>
<param><key>comment</key><value>Represents the transmitter ID.
Using A to represent the bits.</value></param>
<param><key>value</key><value>[ord('A')] * 16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_bits</value></param>
<param><key>comment</key><value>The length byte, converted into bits</value></param>
<param><key>value</key><value>map(int, bin(pktlen )[2:].zfill(8))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>msg</value></param>
<param><key>comment</key><value>The message to send, consists of all 'B'
characters, and one C.</value></param>
<param><key>value</key><value>[ord('B')]*((pktlen*8)-1) + [ord('C')]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pktlen</value></param>
<param><key>comment</key><value>How many bytes to transmit in the
data section.</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word</value></param>
<param><key>comment</key><value>Converts 0xd391 to an array of bits</value></param>
<param><key>value</key><value>map(int, bin(0xd391)[2:].zfill(16))</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>sync_word + host_id + len_bits + msg + csum + [0]*10000</value></param>
</block>
<block>
<key>reveng_packet_deframer</key>
<param><key>id</key><value>reveng_packet_deframer_0</value></param>
<param><key>pkt_len_adtl</key><value>1</value></param>
<param><key>encoding</key><value>none</value></param>
<param><key>big_endian</key><value>True</value></param>
<param><key>pkt_len_idx</key><value>2</value></param>
<param><key>msb</key><value>True</value></param>
<param><key>fixed_len</key><value>False</value></param>
<param><key>name</key><value>RevengTestSrc</value></param>
<param><key>pkt_len</key><value>2</value></param>
<param><key>sync</key><value>sync_word</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>reveng_packet_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>reveng_packet_deframer_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
</flow_graph>
